FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
            file://0001-pseudo-glibc-rtld-next-workaround.patch \
"
