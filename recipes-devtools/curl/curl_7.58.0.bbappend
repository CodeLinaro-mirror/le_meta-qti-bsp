FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
            file://CVE-2018-14618.patch \
"
