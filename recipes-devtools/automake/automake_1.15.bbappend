FILESEXTRAPATHS_prepend := "${THISDIR}/automake:"

SRC_URI += "file://automake_in.patch"

