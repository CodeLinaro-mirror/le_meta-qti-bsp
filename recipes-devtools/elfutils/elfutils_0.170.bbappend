FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Bug-fix-for-missing-const-attribute-of-__elf32_msize.patch \
            file://0001-Ensure-that-packed-structs-follow-the-gcc-memory-lay.patch \
"
