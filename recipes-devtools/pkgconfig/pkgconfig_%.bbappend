SRC_URI_remove = "git://anongit.freedesktop.org/pkg-config"
SRC_URI_prepend = " git://git.codelinaro.org/clo/yocto-mirrors/pkg-config.git;protocol=https;branch=master "
