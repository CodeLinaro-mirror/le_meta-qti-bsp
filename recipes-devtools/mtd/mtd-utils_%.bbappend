FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
           file://0001-mkfs.ubifs-Fix-mkfs.ubifs-failure-with-option-selinu.patch \
           "

