FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Remove-invalid-pure_func-qualifiers.patch  \
"
