SRC_URI_remove = "git://git.savannah.gnu.org/config.git"
SRC_URI_prepend = " git://git.git.savannah.gnu.org/config.git "
