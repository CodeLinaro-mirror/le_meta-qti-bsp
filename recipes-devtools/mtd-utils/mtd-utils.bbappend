FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0005-mkfs.ubifs-Fix-build-with-gcc-5.1.patch"
