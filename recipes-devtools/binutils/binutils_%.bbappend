#Below Package is Fetch from the CLO
BINUTILS_GIT_URI = "git://git.codelinaro.org/clo/le/binutils-gdb.git;protocol=https;branch=caf_migration/binutils-gdb/binutils-${BINUPV}-branch"
