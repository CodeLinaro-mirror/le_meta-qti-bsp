FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Bug-fixes-for-syscall.c.patch  \
"
