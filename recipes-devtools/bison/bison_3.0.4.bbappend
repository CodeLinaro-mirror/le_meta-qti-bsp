FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://110-glibc-change-work-around.patch \
"
