# To fetch go-systemd packages from CAF
SRC_URI = "git://source.codeaurora.org/quic/le/go-systemd.git;protocol=https;branch=go-systemd/main"
