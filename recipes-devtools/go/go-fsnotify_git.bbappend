#Fetch the package from codelinaro
SRC_URI = "git://git.codelinaro.org/clo/le/fsnotify/fsnotify.git;protocol=https;branch=caf_migration/fsnotify/main"

