SRCREV = "253e94c1fa511704baeb61cf69995bbf09ba435e"

SRC_URI = "git://source.codeaurora.org/quic/lc/external/github.com/ninja-build/ninja.git;protocol=git;branch=chromium.org/release"
