SRC_URI:remove = " git://github.com/c-ares/c-ares.git "
SRC_URI:prepend = " git://github.com/c-ares/c-ares.git;protocol=https;branch=main "
