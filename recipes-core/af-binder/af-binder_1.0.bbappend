SRC_URI_git = "git://source.codeaurora.org/quic/le/AGL/apps/src/app-framework-binder;protocol=https;branch=app-framework-binder/dab"
