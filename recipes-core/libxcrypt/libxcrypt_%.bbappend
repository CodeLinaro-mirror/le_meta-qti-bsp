#libxcrypt is fetch from Codelinaro
SRC_URI = "${CLO_LE_GIT}/libxcrypt.git;protocol=https;branch=caf_migration/besser82/master"

