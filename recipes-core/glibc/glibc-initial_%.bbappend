# Adjust branch & URI to fetch from CLO.
SRCBRANCH = "caf_migration/drains/release/${PV}/master"
GLIBC_GIT_URI = "git://git.codelinaro.org/clo/le/glibc.git;protocol=https"

