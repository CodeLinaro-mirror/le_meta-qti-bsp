GLIBC_GIT_URI = "git://source.codeaurora.org/quic/le/glibc;protocol=https"
SRCBRANCH = "drains/release/${PV}/master"
