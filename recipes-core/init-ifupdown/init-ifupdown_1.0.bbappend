FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

INITSCRIPT_PARAMS_mdm9650 = "start 01 S . stop 80 0 6 1 ."
