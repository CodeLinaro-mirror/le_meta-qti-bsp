# When cross compiling for ARM we don't want to include this
RRECOMMENDS_${PN}_remove_arm = "shared-mime-info"
