FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
      	   file://0001-Fix-to-ignore-Wformat-nonliteral-errors.patch \
          "

