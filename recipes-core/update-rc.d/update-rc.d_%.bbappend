SRC_URI = "git://git.codelinaro.org/clo/le/platform/external/update-rc.d;protocol=https;branch=caf_migration/github/master \
          "

PR = "r6"
