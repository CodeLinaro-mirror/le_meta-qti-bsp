LICENSE = "GPLv3+"
LIC_FILES_CHKSUM = "file://COPYING;md5=f27defe1e96c2e1ecd4e0c9be8967949"

ALTERNATIVE_${PN}_remove_sda845 = "find xargs"
