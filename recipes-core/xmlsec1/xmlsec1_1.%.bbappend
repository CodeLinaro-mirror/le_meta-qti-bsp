SRC_URI = "git://source.codeaurora.org/quic/le/xmlsec;branch=terabit/master;protocol=https"

SRC_URI += "https://source.codeaurora.org/quic/le/AGL/meta-agl/plain/meta-app-framework/recipes-support/xmlsec1/xmlsec1/Only-require-libxslt-in-.pc-files-when-necessary.patch?h=automotivelinux/eel&id=f0e87b1656d46b1e72dc89fcf0186065ce804fc4;downloadfilename=Only-require-libxslt-in-.pc-files-when-necessary.patch;md5sum=24c24d441ed2be6e58725b5a677569dd;sha256sum=7d71373f4759a2dcead60788828a2a8306dfef96554c41e18439e64b37f86506"
