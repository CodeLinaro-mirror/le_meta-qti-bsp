RDEPENDS_${PN}_remove = "\
	automotive-message-broker \
    "
