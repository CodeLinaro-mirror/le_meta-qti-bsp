RDEPENDS_${PN}_virtclass-multilib-lib32 =  "\
"

