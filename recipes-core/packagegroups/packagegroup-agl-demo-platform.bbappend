AGL_APPS = " "

RDEPENDS_${PN}_remove = " \
     qtquickcontrols2-agl \
     qtquickcontrols2-agl-style \
     ${MOST_HVAC} \
     "
