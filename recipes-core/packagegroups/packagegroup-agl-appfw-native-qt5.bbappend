RDEPENDS_${PN} += "qtdeclarative-plugins "
