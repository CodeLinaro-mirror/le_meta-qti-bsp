
RDEPENDS_${PN}_remove = "\
        connman \
        connman-client \
        connman-tests \
        connman-tools \
        connman-ncurses \
        "
