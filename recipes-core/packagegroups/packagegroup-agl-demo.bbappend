RDEPENDS_${PN}_remove = " \
     homescreen \
     "
