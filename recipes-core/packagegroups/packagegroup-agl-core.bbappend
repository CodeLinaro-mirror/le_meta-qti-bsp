RDEPENDS_${PN}_remove_8x96autodvrs += "\
    packagegroup-agl-core-connectivity \
    "
