RDEPENDS_${PN}_remove += "\
    lightmediascanner-meta \
    " 
