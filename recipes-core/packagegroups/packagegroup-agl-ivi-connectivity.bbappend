RDEPENDS_${PN}_remove = "\
        ofono \
"
