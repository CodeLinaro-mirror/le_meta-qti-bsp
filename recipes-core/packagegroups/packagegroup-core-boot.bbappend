inherit packagegroup

VIRTUAL-RUNTIME_base-utils-syslog = "rsyslog"