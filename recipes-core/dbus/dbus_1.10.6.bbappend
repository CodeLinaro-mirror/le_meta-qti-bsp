FILESEXTRAPATHS_append := ":${THISDIR}/files"

SRC_URI_append += "file://0002-fix-systemd-logind-kicked-off-by-dbus-.patch"
