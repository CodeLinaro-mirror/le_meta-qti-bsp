DUMMYPROVIDES += "\
    perl-module-config \
    perl-module-warnings-register \
"
