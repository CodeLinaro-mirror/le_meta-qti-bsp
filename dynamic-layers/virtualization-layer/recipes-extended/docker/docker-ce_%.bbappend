SYSTEMD_AUTO_ENABLE:${PN}:kalama = "disable"
SYSTEMD_AUTO_ENABLE:${PN}:qrb5165 = "disable"
