SYSTEMD_AUTO_ENABLE_selinux-init = "disable"
