# semanage needs audit python libs.
RDEPENDS_${BPN}-semanage += "\
        audit-python \
        "
