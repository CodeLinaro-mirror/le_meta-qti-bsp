# Add the libgomp support.
RDEPENDS:${PN} += "\
    libgomp libgomp-dev libgomp-staticdev \
    "
