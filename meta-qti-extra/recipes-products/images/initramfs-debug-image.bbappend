PACKAGE_INSTALL += "makedumpfile"
PACKAGE_INSTALL += "kdump-initscript"
PACKAGE_INSTALL_remove = "initramfs-debug"
