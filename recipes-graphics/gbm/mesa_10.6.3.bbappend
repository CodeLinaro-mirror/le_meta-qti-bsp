do_install_append() {
  rm  ${D}${includedir}/gbm.h
}
