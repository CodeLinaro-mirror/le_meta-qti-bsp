# Remove shared-mime-info even on device
SHAREDMIMEDEP:class-target = ""
