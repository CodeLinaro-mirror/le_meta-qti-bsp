# Remove dependencies as QTI eSDK don't support qemu. 

DEPENDS:remove = "qemu-native"
DEPENDS:remove = "qemu-helper-native"
