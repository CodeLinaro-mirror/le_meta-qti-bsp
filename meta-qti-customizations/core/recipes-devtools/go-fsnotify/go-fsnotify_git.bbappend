#Below CAF is mirror from "github.com/go-fsnotify/fsnotify"
SRC_URI = "git://github.com/fsnotify/fsnotify.git;branch=main;protocol=https"
