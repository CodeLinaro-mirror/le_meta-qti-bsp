#remove of bash from the bash-completion
RDEPENDS:${PN}:remove = "bash"
