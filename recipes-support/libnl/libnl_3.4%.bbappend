FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
        file://0001-attr-mark-nested-attributes-as-NLA_F_NESTED.patch \
"


