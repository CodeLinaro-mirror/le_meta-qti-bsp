PACKAGECONFIG:remove = "gstreamer"

