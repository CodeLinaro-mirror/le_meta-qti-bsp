PACKAGECONFIG:remove = "serial_backend"
