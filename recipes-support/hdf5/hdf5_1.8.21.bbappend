SYSROOT_DIRS += " \
    ${bindir} \
"

