FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Bug-fix-for-namespace-variable.patch \
"
