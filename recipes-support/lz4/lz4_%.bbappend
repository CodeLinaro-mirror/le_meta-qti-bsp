SRC_URI = "git://source.codeaurora.org/quic/le/lz4.git;protocol=https;branch=lz4/dev"

SRC_URI += " \
            file://run-ptest \
           "
