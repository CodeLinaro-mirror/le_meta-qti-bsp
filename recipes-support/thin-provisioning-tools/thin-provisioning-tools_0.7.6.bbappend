
SRC_URI_remove = "git://github.com/jthornber/thin-provisioning-tools"
SRC_URI_prepend = "git://github.com/jthornber/thin-provisioning-tools;branch=main;protocol=https "
