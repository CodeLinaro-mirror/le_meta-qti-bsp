SRC_URI:remove = "git://github.com/jthornber/thin-provisioning-tools"
SRC_URI:prepend = " git://git.codelinaro.org/clo/yocto-mirrors/github/jthornber/thin-provisioning-tools.git;branch=main;protocol=https "
