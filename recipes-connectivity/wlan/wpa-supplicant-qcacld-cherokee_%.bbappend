SYSROOT_DIRS_BLACKLIST += " \
  /usr/include/wpa_ctrl.h \
"
