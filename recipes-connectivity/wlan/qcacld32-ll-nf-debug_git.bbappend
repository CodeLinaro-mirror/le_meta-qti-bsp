SYSROOT_DIRS_BLACKLIST += " \
   /usr/include/qcacld/wlan_nlink_common.h \
"

