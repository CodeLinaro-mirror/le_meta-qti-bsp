SYSROOT_DIRS_BLACKLIST += " \
  /usr/include/wpa_ctrl.h \
  /usr/lib/libwpa_client.so \
"
