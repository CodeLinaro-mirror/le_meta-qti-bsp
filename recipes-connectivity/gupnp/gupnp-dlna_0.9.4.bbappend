GI_DATA_ENABLED="0"
