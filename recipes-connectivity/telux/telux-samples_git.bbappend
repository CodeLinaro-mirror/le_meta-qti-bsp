SYSTEMD_SERVICE_${PN} = "cv2x.service cv2x.target"
SYSTEMD_AUTO_ENABLE = "enable"
