FILESEXTRAPATHS_prepend := "${THISDIR}:"

SRC_URI_append += "file://0001-Disable-creation-of-QCMAP_Client.patch"

