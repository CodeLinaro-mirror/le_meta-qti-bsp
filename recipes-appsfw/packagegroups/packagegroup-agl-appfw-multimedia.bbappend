RDEPENDS_${PN}_remove += "\
    agl-service-mediaplayer \
    "

