PACKAGE_ARCH = "${MACHINE_ARCH}"

DEPENDS += "gperf-native"
