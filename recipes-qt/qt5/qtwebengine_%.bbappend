COMPATIBLE_MACHINE_aarch64 = "(.*)"

DEPENDS += "gperf-native"
