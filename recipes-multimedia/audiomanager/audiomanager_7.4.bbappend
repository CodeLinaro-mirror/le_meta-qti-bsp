INSANE_SKIP_${PN} += "installed-vs-shipped"
RDEPENDS_${PN}_remove = "audiomanager-plugins"
