PR = "r14"

SRC_URI = "${CAF_LE_GIT}/platform/external/yocto-kernel-tools;protocol=${CAF_PROT};branch=yocto/master"
