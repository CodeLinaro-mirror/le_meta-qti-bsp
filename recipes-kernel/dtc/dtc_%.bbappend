# Fetch from the codelinaro location.
SRC_URI = "${CLO_LE_GIT}/dtc.git;protocol=https;branch=caf_migration/dtc/main"
SRC_URI += "file://make_install.patch"
