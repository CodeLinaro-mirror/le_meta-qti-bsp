PACKAGECONFIG_remove = "xz lzo libxm12"
