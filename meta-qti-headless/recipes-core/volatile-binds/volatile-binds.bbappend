
VOLATILE_BINDS = "\
/var/build.prop /etc/build.prop\n\
/var/data /etc/data/\n\
/var/usb /etc/usb/\n\
"

