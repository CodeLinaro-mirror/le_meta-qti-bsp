#Copyright (c) 2022 Qualcomm Innovation Center, Inc. All rights reserved.
#SPDX-License-Identifier: BSD-3-Clause-Clear


export KERNEL_TOOLCHAIN_DIR = "${TMPDIR}/work-shared/kernel-toolchain-${PREFERRED_VERSION_linux-msm}"

export KERNEL_TOOLCHAIN_CLANG = "${KERNEL_TOOLCHAIN_DIR}/clang"

