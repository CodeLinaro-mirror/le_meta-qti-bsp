inherit qti-kernel-arch-clang
