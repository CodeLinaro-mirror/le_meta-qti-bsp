PACKAGECONFIG[qt] = ""
DEPENDS = "dbus libdbus-c++ dbus-c++-native dlt-daemon gpsd"
