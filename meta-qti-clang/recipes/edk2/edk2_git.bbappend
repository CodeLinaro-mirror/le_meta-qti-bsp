DEPENDS += "clang-native"

inherit qticlang

CLANG_BIN_PATH = "${SRC_DIR_ROOT}/prebuilts/clang/host/linux-x86/clang-r416183b/bin/"
