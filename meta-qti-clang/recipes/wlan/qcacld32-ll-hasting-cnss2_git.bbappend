inherit qticlang

DEPENDS += "clang-native"
TOOLCHAIN = "clang"

CLANG_BIN_PATH = "${STAGING_BINDIR_NATIVE}/"