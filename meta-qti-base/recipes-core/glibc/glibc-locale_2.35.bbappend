#Skip from QA error [installed-vs-shipped]
INSANE_SKIP:${PN} += "installed-vs-shipped"
