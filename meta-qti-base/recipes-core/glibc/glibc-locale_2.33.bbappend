#Skip from QA error [installed-vs-shipped]
INSANE_SKIP_${PN} += "installed-vs-shipped"
