
RDEPENDS:${PN} += "\
    packagegroup-qti-core-boot-prop \
    "
