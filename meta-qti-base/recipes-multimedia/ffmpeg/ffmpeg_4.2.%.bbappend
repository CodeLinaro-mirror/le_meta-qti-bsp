#remove x264 and gpl for license
PACKAGECONFIG_remove = "x264 gpl"