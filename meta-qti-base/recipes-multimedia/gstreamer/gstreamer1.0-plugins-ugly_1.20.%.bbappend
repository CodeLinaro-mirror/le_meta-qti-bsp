# remove mpeg2dec, for don't support.
PACKAGECONFIG:remove = "mpeg2dec"
