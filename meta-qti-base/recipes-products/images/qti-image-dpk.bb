require recipes-products/images/machine-image.bb 
