# Remove udisks2 since it is GPLv3
RDEPENDS_${PN}_remove = "udisks2"
