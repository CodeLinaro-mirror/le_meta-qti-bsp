FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://agl-demo.cfg"
