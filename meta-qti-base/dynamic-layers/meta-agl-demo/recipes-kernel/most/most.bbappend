# Build with Clang
inherit qti-kernel-arch-clang

