EXTRA_OECONF += "\
    --enable-vendor-partition \
    --enable-alsalib-support=no \
"
