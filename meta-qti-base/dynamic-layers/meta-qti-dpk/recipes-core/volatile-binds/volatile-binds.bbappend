
VOLATILE_BINDS += "\
/var/build.prop /vendor/etc/build.prop\n\
/var/data /vendor/etc/data/\n\
/var/usb /vendor/etc/usb/\n\
/var/misc/wifi /vendor/etc/misc/wifi/\n\
/var/bluetooth /vendor/etc/bluetooth/\n\
/var/allplay /vendor/etc/allplay/\n\
/var/smack/accesses.d /vendor/etc/smack/accesses.d/\n\
"
