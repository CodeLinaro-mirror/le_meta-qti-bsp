FILESEXTRAPATHS:append := ":${THISDIR}/files"

SRC_URI:append = "  file://0001-dbus-Support-search-conf-file-from-vendor-partition.patch"
