FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-libkmod-change-linux-module-directory-for-vendor-build.patch"
