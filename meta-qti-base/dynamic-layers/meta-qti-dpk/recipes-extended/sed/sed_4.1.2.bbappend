# FIXME: sed-4.1.2-r7 do_package: QA Issue: sed: Files/directories were installed but not shipped in any package: /usr
INSANE_SKIP:${PN} += "installed-vs-shipped"
