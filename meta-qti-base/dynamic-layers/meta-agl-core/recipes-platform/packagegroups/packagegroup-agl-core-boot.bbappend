# Match addition made to OE's packagegroup-core-boot
RDEPENDS:${PN} += "packagegroup-qti-core-boot-prop"
