# Match meta-qti-base weston bbappend change
REQUIRED_DISTRO_FEATURES_remove = "opengl"

