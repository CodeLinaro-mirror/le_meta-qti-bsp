FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://0040-libatomic-Do-not-enforce-march-on-aarch64.patch"
