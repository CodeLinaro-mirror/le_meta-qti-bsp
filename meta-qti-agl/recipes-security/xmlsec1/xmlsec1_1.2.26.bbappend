SRC_URI = "${CLO_LE_GIT}/xmlsec;branch=terabit/master;protocol=${CLO_PROTOCOL}"
SRCREV = "72a0a04283b45ec7a626759a323cc3f6517eba34"

S = "${WORKDIR}/git"
