DEPENDS += "glib-2.0-native gobject-introspection gobject-introspection-native prelink-native qemu-native"
