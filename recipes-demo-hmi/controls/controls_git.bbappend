SRC_URI = "git://source.codeaurora.org/quic/le/AGL/apps/controls.git;protocol=https;branch=apps-controls/eel"

REMOVE_LIBTOOL_LA = "0"
