REMOVE_LIBTOOL_LA = "0"

DEPENDS += " qtbase-native"
