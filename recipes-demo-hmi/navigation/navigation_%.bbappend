DEPENDS_remove = "virtual/libgl"

DEPENDS_remove = "af-main"
RDEPENDS_${PN}_remove = "flite openjtalk"

REMOVE_LIBTOOL_LA = "0"
