
DEPENDS =        "glib-2.0 freetype sqlite3 wayland zlib expat openssl virtual/libgles2 virtual/egl wayland"
