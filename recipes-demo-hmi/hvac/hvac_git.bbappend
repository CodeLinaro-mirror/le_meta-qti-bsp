SRC_URI = "git://source.codeaurora.org/quic/le/AGL/apps/hvac.git;protocol=https;branch=apps/hvac/eel"

REMOVE_LIBTOOL_LA = "0"
