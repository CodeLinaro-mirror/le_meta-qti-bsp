SRC_URI = "git://source.codeaurora.org/quic/le/AGL/apps/dashboard.git;protocol=https;branch=apps-dashboard/dab"

REMOVE_LIBTOOL_LA = "0"
