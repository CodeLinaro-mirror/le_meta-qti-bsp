SRC_URI = "git://source.codeaurora.org/quic/le/AGL/apps/mixer.git;protocol=https;branch=apps/mixer/eel"

REMOVE_LIBTOOL_LA = "0"
