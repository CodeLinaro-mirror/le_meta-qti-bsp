SRC_URI = "git://source.codeaurora.org/quic/le/AGL/apps/mediaplayer.git;protocol=https;branch=apps/mediaplayer/eel"

REMOVE_LIBTOOL_LA = "0"
