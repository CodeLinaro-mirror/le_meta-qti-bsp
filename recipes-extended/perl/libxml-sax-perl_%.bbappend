do_populate_sysroot[depends] += "libxml-namespacesupport-perl-native:do_populate_sysroot"
do_populate_sysroot[depends] += "libxml-sax-base-perl-native:do_populate_sysroot"
