ALTERNATIVE_PRIORITY := " "
RDEPENDS_${PN}_remove = "${PN}-ping"
