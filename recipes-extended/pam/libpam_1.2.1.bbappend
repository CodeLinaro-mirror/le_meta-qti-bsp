EXTRA_OECONF += " --disable-selinux"
