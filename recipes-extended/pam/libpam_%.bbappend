FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fix-locale-header.patch \
"
